# Keil uVision project stm32f1.uvprojx, settings and files
target stm32f1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;       ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SCSLib
    ../SCSLib/: SCS.c SCSCL.c SCSerail.c SMS_STS.c HLS.c
  group examples/SCSCL
    ../examples/SCSCL/: Broadcast.c FeedBack.c ProgramEprom.c RegWritePos.c SyncWritePos.c WritePos.c WritePWM.c
  group examples/SMS_STS
    ../examples/SMS_STS/: Broadcast.c FeedBack.c ProgramEprom.c RegWritePos.c SyncWritePos.c WritePos.c WriteSpe.c SyncRead.c
  group examples/HLS
    ../examples/HLS/: Broadcast.c FeedBack.c ProgramEprom.c RegWritePos.c SyncRead.c SyncWritePos.c WritePos.c WriteSpe.c
  group examples/
    ../examples/: Ping.c
software components: CMSIS:CORE 4.3.0
